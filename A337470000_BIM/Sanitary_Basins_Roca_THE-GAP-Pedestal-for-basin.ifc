Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Basins_Roca_THE-GAP-Pedestal-for-basin.ifc.ifc
Time: 2021-12-15T18:51:13
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement
ePset_BIMobjectScript - COLOR: WHITE; LOD: 300
ePset_BIMobject_BO - IfcClassification (BO_ifcclas): Furnishing Element
